# Keil uVision project ECE353-S16-HW3.uvprojx, settings and files
target ECE353-S16-HW3 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;../include;../drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c interrupts.c boardUtil.c img.c draw.c
  group headers
    ../include/: adc.h driver_defines.h gpio_port.h
    ./: interrupts.h
  group Drivers
    ../drivers/: adc.c gpio_port.c timers.c eeprom.c fonts.c i2c.c lcd.c pc_buffer.c spi.c uart.c uart_irqs.c wireless.c
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
